# Keil uVision project Demo.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F100C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Demo
  c flags: Optim=1
  c define: STM32F10X_MD, USE_STDPERIPH_DRIVER
  c include: .\User;.\Lib\CMSIS\CM3\DeviceSupport\ST\STM32F10x;.\Lib\CMSIS\CM3\CoreSupport;.\Lib\STM32F10x_StdPeriph_Driver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Start
    ./Lib/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_md.s
  group Lib
    ./Lib/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c stm32f10x_it.c
    ./Lib/CMSIS/CM3/CoreSupport/: core_cm3.c
    ./Lib/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group User
    ./User/: main.c Led_Key.c bsp_exti.c bsp_SysTick.c bsp_iwdg.c bsp_wwdg.c bsp_uart.c bsp_dma.c bsp_adc.c bsp_rtc.c bsp_tim.c music.c bsp_hcsr04.c bsp_spi_max6675.c bsp_digital_tube.c bsp_74HC595.c bsp_lcd1602.c bsp_ds18b20.c bsp_iic_at24c02.c bsp_iic.c bsp_iic_bh1750.c bsp_uln2003.c bsp_tcs3200.c bsp_dht11.c bsp_oled.c
