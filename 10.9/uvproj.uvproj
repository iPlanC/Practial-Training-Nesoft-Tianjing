# Keil uVision project uvproj.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F102C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x200027FF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: uvproj +hex
  c flags: Optim=1
  c define: STM32F10X_MD, USE_STDPERIPH_DRIVER
  c include: .\lib\CMSIS\CM3\CoreSupport;.\lib\CMSIS\CM3\DeviceSupport\ST\STM32F10x;.\lib\STM32F10x_StdPeriph_Driver\inc;.\user
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2800
  group lib
    ./lib/CMSIS/CM3/CoreSupport/: core_cm3.c
    ./lib/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: stm32f10x_it.c system_stm32f10x.c
    ./lib/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group start
    ./lib/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_md.s
  group user
    ./user/: main.c mylib.c
